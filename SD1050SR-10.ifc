Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2018-01-10T12:51:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160217_0900(x64) - Exporter 17.0.411.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 10 12:51:18 2018 * Host: DESKTOP-AKA7PPN * Database: C:\Users\DEANJO~1\AppData\Local\Temp\{38067963-FBC7-49C6-8322-C231BF0728C1}\ifc * Database version: 5507 * Database creation date: Wed Jan 10 12:51:17 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 10 12:51:17 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 10 12:51:17 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy, d63a0583-b451-4e78-9db6-de595fed83e3:d63a0583-b451-4e78-9db6-de595fed83e3:199721
In: Level 1
Type - Material: Stainless - Brushed
Type - Identity Data - Cost: 0; Description: Ibiza - Inset hospital sinktops; Manufacturer: Plandstainless Ltd; Model: SD1050SR-10; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; URL: www.plandstainless.co.uk
Type - Model Properties - Area: 1.67492 m2; Authority: Dean Johnson; Catalog web link: www.plandstainless.co.uk; Category: Healthcare; Center of Gravity: X: 598.7 mm Y: -34.7 mm Z: 253.1 mm; COBie AssetType: Fixed; COBie CreatedBy: Robin Hardcastle; COBie CreatedOn: 43110.00; COBie DocumentationLiterature: www.plandstainless.co.uk; COBie DurationUnit: Years; COBie ExpectedLife: 30.00; COBie Features: Single Bowl, Right Hand Drainer; COBie Finish: Satin/polished; COBie Grade: 304 1.4301; COBie Manufacturer: Plandstainless Ltd; COBie Material: Stainless Steel; COBie ModelNumber: SD1050SR-10; COBie Size: 1028 x 500mm; COBie WarrantyDescription: Manufacturer's Warranty; COBie WarrantyDurationUnit: Years; COBie WarrantyDurrationParts: 2.00; COBie WarrantyGuarantorParts: YES; Company: Plandstainless Ltd; Density: 226.535; Design Status: 3; Manager: Dean Johnson; Mass: 1.328517e+01 kilogram; Material: Stainless Steel, Austenitic; Part Number: SD1050SR-10; Project: Healthcare; Requested Accuracy: Low; Title: Ibiza - Inset hospital sinktops; Volume: 0.00166065 m3
Type - Other - Category: Specialty Equipment
Pset_ManufacturerTypeInformation - Manufacturer: Plandstainless Ltd
Constraints - Offset: 0 mm
Dimensions - Area: 0.808904 m2; Volume: 0.099202 m3
Other - Family: d63a0583-b451-4e78-9db6-de595fed83e3: d63a0583-b451-4e78-9db6-de595fed83e3; Family and Type: d63a0583-b451-4e78-9db6-de595fed83e3: d63a0583-b451-4e78-9db6-de595fed83e3; Type: d63a0583-b451-4e78-9db6-de595fed83e3: d63a0583-b451-4e78-9db6-de595fed83e3; Type Id: d63a0583-b451-4e78-9db6-de595fed83e3: d63a0583-b451-4e78-9db6-de595fed83e3
Phasing - Phase Created: New Construction
